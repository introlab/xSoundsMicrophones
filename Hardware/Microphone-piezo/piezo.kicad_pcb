# Repository introlab/xSoundsMicrophones

File README.md:

# xSoundsMicrophones
Microphones for 8SoundsUSB and 16SoundsUSB. 

These microphones and sound cards require the use of "crossover" cables with RJ11, RJ12 or RJ14 connectors. 

# Compatibility
* [16SoundsUSB](https://github.com/introlab/16SoundsUSB)
* [8SoundsUSB](https://eightsoundsusb.sourceforge.net)

## KiCad design Hardware/Microphone-piezo/piezo.kicad_pcb

File Hardware/Microphone-piezo/README:

A impedance buffer and amplifier for the xSoundsMicrophones project.

The problem with piezoelectric and contact mics is that they are not well matched to typical audio inputs. 
The reason why these devices often sound tinny is because the piezo sensor presents its signal through a series capacitance which is small, typically 15nF or less. When wired to a normal 50 kilohm line input this forms a 200Hz high-pass filter, which eliminates the bass. 
Because the piezo disc has a very high impedance (1 MΩ typical), it should be buffered to avoid possible impedance mismatch with an existing audio system. This circuit acts as a impedance buffer, and some amplification does not hurt as long as it is around 40dB. 
The best piezoelectric sensors for listening is based on Aluminum Nitride and molybdenum. PZT-5 also known as SensorTech BM500,Channel 5500,Morgan PZT5A1 is widely used.

The diodes are there to avoid overloading the circuit if it is dropped or bumped in to something hard.

NOAA technical memorandum NMFS 2008NOAA-TM-NMFS-SWFSC-417 also known as
A guide to constructing hydrophones and hydrophone arrays for monitoring marine mammal vocalizations,
describes how to build a single crystal hydrophone.

If the piezo electric crystals are a suitable distance and 45° degrees apart from each other in a flat circular array with 8  piezoelectric sensors,
they should be compatible with Manyears or ODAS.

Approximate values for fresh water and seawater, respectively, at surface pressure are 1450 around 1500 m/s.
The speed of sound in water increases with increasing pressure, temperature and salinity.

Also, read: https://github.com/Supermagnum/passiveSonar

Parts:
C1, C4, C6: 10uF; CP_Elec_5x5.9
C2, C3: 47uF; CP_Elec_5x5.9
C5: 0.1uF; CP_Elec_5x5.9
D1, D2: 1N4148W; D_SOD-123
J1: RJ14; RJ14_Connfly_DS1133-S4_Horizontal
J2: conn to ground; MountingHole_2.2mm_M2_DIN965_Pad
J3, J4, J5: Conn_01x01_Female; MountingHole_2.2mm_M2_DIN965_Pad
R1: 1M; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R2, R3: 56K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4: 1K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R5: 10K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: 470; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R7: 100K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R8: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: LME49724; DDA0008B
X1: Piezo; Crystal_HC18-U_Vertical

Connections:
GND: C1.2, C2.2, C3.1, C5.2, D2.2 (A), J1.2, J2.1, J3.1, J4.1, J5.1, R3.2, R7.1, U1.6, X1.2
unnamed: C1.1, R1.2, R2.2, R3.1
unnamed: C3.2, R4.1
unnamed: C4.1, J1.1, R7.2
unnamed: C4.2, R6.1
unnamed: C5.1, U1.2
unnamed: C6.1, J1.3
unnamed: C6.2, R9.1
unnamed: D1.2 (A), D2.1 (K), R1.1, R8.2, U1.1, X1.1
unnamed: R4.2, R5.2, U1.8
unnamed: R5.1, R9.2, U1.5
unnamed: R6.2, R8.1, U1.4
VCC: C2.1, D1.1 (K), J1.4, R2.1, U1.3, U1.7

Board: 2 copper layers, 51.5 x 32.0 mm, 24 parts (0 on the bottom side), 13 nets.

## Commit log

2018-01-24 Add files via upload
    Added license file.
2018-04-30 Initial commit.
2018-04-30 Fix for readability
2018-08-02 Update README.md
    added note regarding type of cables (crossover)
2018-11-08 initial commit: StereoJackAdapter PCB
2020-07-28 added a pcb for a piezo electric element
2020-07-28 Add files via upload
    added picture of board dimentions
2020-07-29 Add files via upload
    updated files
2020-07-29 updated files
    updated files.
2020-07-30 Add files via upload
    updated gerber files,
2020-07-30 Add files via upload
    Added a pair of zeners as a waveform clipper to protect the opamp inputs against damaging voltage spikes.
    Also, updated pictures and other files.
2020-07-30 Update README
    Updated readme.
2020-08-01 added
    Added LME49724 cooling footprint vias and CU backside.
2021-04-09 Add files via upload
    Updated gerber files
2021-04-09 Add files via upload
    updated corrected schema
2021-04-12 updated gerbers
2021-04-12 updated files
2021-04-12 updated readme fule
2021-04-13 Hopefully the final update
2021-04-13 Final update, all should be OK now!
